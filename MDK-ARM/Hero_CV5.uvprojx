# Keil uVision project Hero_CV5.uvprojx, settings and files
target Hero_CV5 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: basic
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Inc/Algorithm;../Inc/Application;../Inc/etc;../Inc/Library;../Inc/Modules;../Inc/Periphal;../Inc/Protocol;../Inc/System;../Inc/Utility;../Drivers/CMSIS/DSP/Include
  asm include: ../Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application
    ../Src/Application/: app_communicate.c app_init.c app_gimbal.c app_ins.c app_watchDog.c app_remote.c app_shoot.c app_referee.c app_autoaim.c app_chassis.c app_power_limit.c
  group Modules
    ../Src/Modules/: module_referee.c module_gimbal.c module_shoot.c module_chassis.c module_supercap.c
  group Periphal
    ../Src/Periphal/: periph_bmi088.c periph_motor.c periph_referee.c periph_remote.c periph_servo.c periph_autoaim.c
  group Utility
    ../Src/Utility/: util_can.c util_flash.c util_gpio.c util_pwm.c util_spi.c util_uart.c util_debug.c
  group System
    ../Src/System/: sys_const.c sys_dwt.c sys_softTimer.c
  group Algorithm
    ../Src/Algorithm/: alg_crc.c alg_filter.c alg_kalman.c alg_math.c alg_pid.c alg_quaternionEKF.c alg_power_limit.c
  group Library
    ../Src/Library/: lib_buff.c lib_delay.c
    ../Src/: arm_cortexM4lf_math.lib
  group Protocol
    ../Src/Protocol/: protocol_common.c protocol_receive.c protocol_transmit.c
software components: CMSIS:CORE 6.1.0
